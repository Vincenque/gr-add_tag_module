options:
  parameters:
    generate_options: qt_gui
    id: testTagModule
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: burst
  id: variable_qtgui_push_button
  parameters:
    label: Start recording
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: burst
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Burst
    'true': 'True'
    type: bool
    value: 'True'
  states: {state: disabled}
- name: file_name
  id: variable_qtgui_entry
  parameters:
    label: 'Set file name:'
    type: string
    value: test
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: scale_factor
  id: variable
  parameters:
    value: '255'
  states: {}
- name: add_tag_module_add_tag_0
  id: add_tag_module_add_tag
  parameters:
    burst: burst
    file: file_name
    num_ports: '4'
    number_of_samples_to_record: int(2e6)
    type: complex
    vlen: '1'
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: scale_factor
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: scale_factor
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: scale_factor
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: scale_factor
    vector_output: 'False'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: triangle.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: modified_tagged_file_sink_module_modified_tagged_file_sink_0
  id: modified_tagged_file_sink_module_modified_tagged_file_sink
  parameters:
    append: 'False'
    file: file_name+"_ch1_int16"
    samp_rate: int(samp_rate)
    type: short
    vlen: '1'
  states: {}
- name: modified_tagged_file_sink_module_modified_tagged_file_sink_0_0
  id: modified_tagged_file_sink_module_modified_tagged_file_sink
  parameters:
    append: 'False'
    file: file_name+"_ch2_int16"
    samp_rate: int(samp_rate)
    type: short
    vlen: '1'
  states: {}
- name: modified_tagged_file_sink_module_modified_tagged_file_sink_0_0_0
  id: modified_tagged_file_sink_module_modified_tagged_file_sink
  parameters:
    append: 'False'
    file: file_name+"_ch3_int16"
    samp_rate: int(samp_rate)
    type: short
    vlen: '1'
  states: {}
- name: modified_tagged_file_sink_module_modified_tagged_file_sink_0_0_0_0
  id: modified_tagged_file_sink_module_modified_tagged_file_sink
  parameters:
    append: 'False'
    file: file_name+"_ch4_int16"
    samp_rate: int(samp_rate)
    type: short
    vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: int(1e4)
    srate: samp_rate
    type: complex
  states: {}

connections:
- [add_tag_module_add_tag_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [add_tag_module_add_tag_0, '1', blocks_complex_to_interleaved_short_0_0, '0']
- [add_tag_module_add_tag_0, '2', blocks_complex_to_interleaved_short_0_0_0, '0']
- [add_tag_module_add_tag_0, '3', blocks_complex_to_interleaved_short_0_0_0_0, '0']
- [add_tag_module_add_tag_0, '3', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', modified_tagged_file_sink_module_modified_tagged_file_sink_0, '0']
- [blocks_complex_to_interleaved_short_0_0, '0', modified_tagged_file_sink_module_modified_tagged_file_sink_0_0, '0']
- [blocks_complex_to_interleaved_short_0_0_0, '0', modified_tagged_file_sink_module_modified_tagged_file_sink_0_0_0, '0']
- [blocks_complex_to_interleaved_short_0_0_0_0, '0', modified_tagged_file_sink_module_modified_tagged_file_sink_0_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', add_tag_module_add_tag_0, '0']
- [blocks_throttle2_0, '0', add_tag_module_add_tag_0, '1']
- [blocks_throttle2_0, '0', add_tag_module_add_tag_0, '2']
- [blocks_throttle2_0, '0', add_tag_module_add_tag_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
